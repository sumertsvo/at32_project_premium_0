# Keil uVision project project_0.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F421K8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: project_0
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:at32f421_conf 2.0.0, Device:at32f421_firmware_library:adc 2.0.0, Device:at32f421_firmware_library:cmp 2.0.0, Device:at32f421_firmware_library:crm 2.0.0, Device:at32f421_firmware_library:ertc 2.0.0, Device:at32f421_firmware_library:exint 2.0.0, Device:at32f421_firmware_library:gpio 2.0.0, Device:at32f421_firmware_library:misc 2.0.0, Device:at32f421_firmware_library:pwc 2.0.0, Device:at32f421_firmware_library:scfg 2.0.0, Device:at32f421_firmware_library:tmr 2.0.0, Device:at32f421_firmware_library:usart 2.0.0, Device:at32f421_firmware_library:wdt 2.0.0, Device:startup 2.0.0
